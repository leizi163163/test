# Keil uVision project STM32_DEMO.uvprojx, settings and files
target STM32_DEMO (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32_DEMO +hex
  AfterMake: fromelf.exe --bin -o ..\..\Output\Project_MC_Hand.bin ..\..\Output\STM32_DEMO.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\..\CMSIS;..\..\FWlib\inc;..\..\USER;..\..\HARDWARE;..\..\Modules;..\..\LetterShell
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTCODE
    ../../CMSIS/startup/arm/: startup_stm32f10x_hd.s
  group USER
    ../../USER/: main.c stm32f10x_it.c USER_SYSTick.c stm32f10x_conf.h ANT_Config.c CommandProcess.c dsrc_fun.c
  group FWlib
    ../../FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../../CMSIS/: core_cm3.c system_stm32f10x.c
  group HARDWARE
    ../../HARDWARE/: HARD_USART.c HARD_NVIC.c HARD_IWDG.c
  group Modules
    ../../Modules/: PSAM.c PsamApp.c slm_api.c slm_app.c slm_spi.c BK5824.c BK5823TX.c
  group LetterShell
    ../../LetterShell/: shell.c shell_cmd_list.c shell_companion.c shell_ext.c shell_port.c
